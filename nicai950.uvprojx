# Keil uVision project nicai950.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: -AT32A403AVGT7 ArteryTek
  pack: ArteryTek.AT32A403A_DFP.2.0.8
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(200000000) ELITTLE
  output: nicai950 +hex
  AfterMake: Hex2Btf950.exe Objects\nicai950.hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: Device\include;Device\Firmware\Peripherals\inc;Device\Utilities;CMSIS;Source
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xfd000
  memory RVCT9: RAM 0x20000800 size 0x17800
  group Source
    ./Source/: main.c board.c display.c radio.c services.c packet.c
  group Device_Peripherals
    ./Device/Firmware/Peripherals/src/: at32a403a_acc.c at32a403a_adc.c at32a403a_bpr.c at32a403a_can.c at32a403a_crc.c at32a403a_crm.c at32a403a_dac.c at32a403a_debug.c at32a403a_dma.c at32a403a_emac.c at32a403a_exint.c at32a403a_flash.c at32a403a_gpio.c at32a403a_i2c.c at32a403a_misc.c at32a403a_pwc.c at32a403a_rtc.c at32a403a_sdio.c at32a403a_spi.c at32a403a_tmr.c at32a403a_usart.c at32a403a_usb.c at32a403a_wdt.c at32a403a_wwdt.c at32a403a_xmc.c
  group Device_System
    ./Device/Source/: system_at32a403a.c
    ./Device/Source/ARM/: startup_at32a403a.s
